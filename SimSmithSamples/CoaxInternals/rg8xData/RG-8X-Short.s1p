! ListType=Log
!!Belden 9258 RG-8X Short
# MHz S RI R 50
! Worked out from all points (reflecting one-port):
!   100 points, 10 kHz to 100 MHz, reference 50 ohm
!   lowest |S11| = -2.2 dB at 100 MHz (marker M1), VSWR 8.08, Z = 6.82 + j15.8 ohm
!   phase of S11 starts at 180 deg and turns -1475 deg over the sweep
!   the Smith chart shows 68.93 MHz to 100 MHz only
!   S11 on the Smith chart (normalised r, x): 68.93 MHz: 1.29, -3.12; 75.65 MHz: 0.13, +0.42; 83.02 MHz: 0.27, -1.11; 91.12 MHz: 0.77, +2.23; 100 MHz: 0.14, +0.32
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! magnitudes (dB):
! f  S11
! 10 kHz  -0.1
! 10.97 kHz  -0.1
! 12.04 kHz  -0.2
! 13.22 kHz  -0.1
! 33.52 kHz  -0.1
! 102.4 kHz  -0.1
! 343 kHz  -0.2
! 1.048 MHz  -0.3
! 3.199 MHz  -0.5
! 4.229 MHz  -0.5
! 8.111 MHz  -0.5
! 9.77 MHz  -0.5
! 10.72 MHz  -0.6
! 14.17 MHz  -0.8
! 15.56 MHz  -0.9
! 20.57 MHz  -0.9
! 22.57 MHz  -1.0
! 27.19 MHz  -1.1
! 32.75 MHz  -1.2
! 35.94 MHz  -1.3
! 39.44 MHz  -1.4
! 47.51 MHz  -1.5
! 62.8 MHz  -1.7
! 68.93 MHz  -1.8
! 75.65 MHz  -1.9
! 83.02 MHz  -2.0
! 91.12 MHz  -2.1
! 100 MHz  -2.2
