! ListType=Log
!!Belden 9258 RG-8X Open
# MHz S RI R 50
! Worked out from all points (reflecting one-port):
!   100 points, 10 kHz to 100 MHz, reference 50 ohm
!   lowest |S11| = -2.3 dB at 100 MHz (marker M1), VSWR 7.73, Z = 47 - j117 ohm
!   phase of S11 starts at -0 deg and turns -1481 deg over the sweep
!   the Smith chart shows 68.93 MHz to 100 MHz only
!   S11 on the Smith chart (normalised r, x): 68.93 MHz: 0.11, +0.32; 75.65 MHz: 0.54, -1.94; 83.02 MHz: 0.20, +0.91; 91.12 MHz: 0.13, -0.33; 100 MHz: 0.94, -2.35
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! magnitudes (dB):
! f  S11
! 10 kHz  0.0
! 12.04 kHz  0.0
! 13.22 kHz  0.0
! 33.52 kHz  0.0
! 102.4 kHz  0.0
! 343 kHz  0.0
! 1.048 MHz  0.0
! 2.009 MHz  -0.1
! 3.199 MHz  -0.1
! 3.854 MHz  -0.2
! 4.642 MHz  -0.3
! 8.111 MHz  -0.7
! 9.77 MHz  -0.7
! 10.72 MHz  -0.7
! 14.17 MHz  -0.7
! 15.56 MHz  -0.7
! 17.07 MHz  -0.8
! 20.57 MHz  -1.0
! 22.57 MHz  -1.0
! 27.19 MHz  -1.0
! 29.84 MHz  -1.1
! 32.75 MHz  -1.2
! 39.44 MHz  -1.3
! 68.93 MHz  -1.8
! 75.65 MHz  -1.9
! 83.02 MHz  -1.9
! 91.12 MHz  -2.1
! 100 MHz  -2.3
