! ListType=Log
!!Belden 8241 10 kHz Short
# MHz S RI R 50
! Worked out from all points (one-port):
!   100 points, 10 kHz to 100 MHz, reference 50 ohm
!   lowest |S11| = -3.7 dB at 100 MHz (marker M1), VSWR 4.78, Z = 10.5 - j4.37 ohm
!   |S11| at or under -10 dB: nowhere
!   the Smith chart shows 68.93 MHz to 100 MHz only
!   S11 on the Smith chart (normalised r, x): 68.93 MHz: 0.25, -0.96; 75.65 MHz: 0.36, +1.61; 83.02 MHz: 0.32, -1.11; 91.12 MHz: 0.72, +2.44; 100 MHz: 0.21, -0.09
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! magnitudes (dB):
! f  S11
! 10 kHz  -0.5
! 33.52 kHz  -0.5
! 102.4 kHz  -0.5
! 343 kHz  -0.6
! 1.048 MHz  -0.6
! 3.199 MHz  -0.5
! 7.391 MHz  -0.3
! 10.72 MHz  -0.5
! 14.17 MHz  -1.0
! 15.56 MHz  -1.0
! 20.57 MHz  -0.6
! 22.57 MHz  -0.7
! 24.77 MHz  -0.9
! 27.19 MHz  -1.4
! 29.84 MHz  -1.5
! 32.75 MHz  -1.0
! 35.94 MHz  -0.9
! 39.44 MHz  -1.3
! 43.29 MHz  -2.1
! 47.51 MHz  -1.2
! 52.14 MHz  -1.3
! 57.22 MHz  -2.6
! 62.8 MHz  -1.3
! 68.93 MHz  -2.3
! 75.65 MHz  -1.7
! 83.02 MHz  -2.5
! 91.12 MHz  -1.7
! 100 MHz  -3.7
