! ListType=Log
!!Belden 8241 10 kHz Open
# MHz S RI R 50
! Worked out from all points (one-port):
!   100 points, 10 kHz to 100 MHz, reference 50 ohm
!   lowest |S11| = -3.0 dB at 91.12 MHz (marker M1), VSWR 5.79, Z = 13.3 - j36 ohm
!   |S11| at or under -10 dB: nowhere
!   the Smith chart shows 68.93 MHz to 100 MHz only
!   S11 on the Smith chart (normalised r, x): 68.93 MHz: 0.42, +1.91; 75.65 MHz: 0.33, -1.23; 91.12 MHz: 0.27, -0.72; 100 MHz: 3.70, +4.93
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! magnitudes (dB):
! f  S11
! 10 kHz  0.0
! 33.52 kHz  0.0
! 102.4 kHz  0.0
! 343 kHz  0.0
! 1.048 MHz  0.0
! 3.199 MHz  -0.1
! 4.642 MHz  -0.2
! 8.111 MHz  -0.7
! 10.72 MHz  -0.6
! 15.56 MHz  -0.5
! 17.07 MHz  -0.6
! 20.57 MHz  -1.2
! 22.57 MHz  -1.3
! 27.19 MHz  -0.8
! 29.84 MHz  -0.8
! 32.75 MHz  -1.3
! 35.94 MHz  -1.8
! 39.44 MHz  -1.3
! 43.29 MHz  -1.0
! 47.51 MHz  -1.8
! 52.14 MHz  -1.9
! 57.22 MHz  -1.2
! 62.8 MHz  -2.5
! 68.93 MHz  -1.5
! 75.65 MHz  -2.2
! 83.02 MHz  -1.7
! 91.12 MHz  -3.0
! 100 MHz  -1.7
