! ListType=Log
!!Belden 8241 Short
# MHz S RI R 50
! Worked out from all points (one-port):
!   100 points, 100 kHz to 100 MHz, reference 50 ohm
!   lowest |S11| = -3.7 dB at 100 MHz (marker M1), VSWR 4.80, Z = 10.5 - j4.22 ohm
!   |S11| at or under -10 dB: nowhere
!   the Smith chart shows 75.65 MHz to 100 MHz only
!   S11 on the Smith chart (normalised r, x): 75.65 MHz: 0.36, +1.61; 81.11 MHz: 0.95, -2.73; 86.97 MHz: 0.19, +0.34; 93.26 MHz: 9.05, +3.94; 100 MHz: 0.21, -0.08
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! magnitudes (dB):
! f  S11
! 100 kHz  -0.5
! 247.7 kHz  -0.5
! 572.2 kHz  -0.6
! 1.417 MHz  -0.6
! 3.275 MHz  -0.5
! 7.565 MHz  -0.3
! 10.72 MHz  -0.5
! 14.17 MHz  -1.0
! 15.2 MHz  -1.0
! 18.74 MHz  -0.7
! 23.1 MHz  -0.7
! 28.48 MHz  -1.6
! 32.75 MHz  -1.0
! 35.11 MHz  -0.9
! 37.65 MHz  -1.0
! 43.29 MHz  -2.1
! 46.42 MHz  -1.4
! 49.77 MHz  -1.1
! 53.37 MHz  -1.6
! 57.22 MHz  -2.6
! 61.36 MHz  -1.5
! 65.79 MHz  -1.4
! 70.55 MHz  -2.9
! 75.65 MHz  -1.7
! 81.11 MHz  -1.8
! 86.97 MHz  -3.0
! 93.26 MHz  -1.6
! 100 MHz  -3.7
