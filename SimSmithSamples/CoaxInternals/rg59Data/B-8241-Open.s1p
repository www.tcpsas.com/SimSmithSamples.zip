! ListType=Log
!!Belden 8241 Open
# MHz S RI R 50
! Worked out from all points (one-port):
!   100 points, 100 kHz to 100 MHz, reference 50 ohm
!   lowest |S11| = -3.5 dB at 93.26 MHz (marker M1), VSWR 5.08, Z = 9.86 + j1.31 ohm
!   |S11| at or under -10 dB: nowhere
!   the Smith chart shows 75.65 MHz to 100 MHz only
!   S11 on the Smith chart (normalised r, x): 75.65 MHz: 0.33, -1.24; 81.11 MHz: 0.22, +0.76; 86.97 MHz: 5.89, -5.40; 93.26 MHz: 0.20, +0.03; 100 MHz: 3.54, +4.97
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! magnitudes (dB):
! f  S11
! 100 kHz  0.0
! 247.7 kHz  0.0
! 572.2 kHz  0.0
! 1.417 MHz  0.0
! 3.275 MHz  -0.1
! 7.565 MHz  -0.7
! 14.17 MHz  -0.5
! 16.3 MHz  -0.5
! 18.74 MHz  -0.9
! 21.54 MHz  -1.3
! 28.48 MHz  -0.7
! 30.54 MHz  -0.9
! 35.11 MHz  -1.8
! 37.65 MHz  -1.6
! 40.37 MHz  -1.1
! 43.29 MHz  -1.0
! 46.42 MHz  -1.4
! 49.77 MHz  -2.3
! 53.37 MHz  -1.6
! 57.22 MHz  -1.2
! 61.36 MHz  -1.9
! 65.79 MHz  -2.4
! 70.55 MHz  -1.4
! 75.65 MHz  -2.2
! 81.11 MHz  -2.4
! 86.97 MHz  -1.6
! 93.26 MHz  -3.5
! 100 MHz  -1.6
