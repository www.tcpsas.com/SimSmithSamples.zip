# MHz S RI R 50.0
! Worked out from all points (one-port):
!   256 points, 1 MHz to 256 MHz, reference 50 ohm
!   lowest |S11| = -45.8 dB at 131 MHz (marker M1), VSWR 1.01, Z = 50.3 + j0.396 ohm
!   |S11| at or under -10 dB: 100.5 MHz to 118.2 MHz (17.64 MHz wide, 16.1 % of centre); 143.4 MHz to 163 MHz (19.6 MHz wide, 12.8 % of centre); 164.6 MHz to end of sweep (the widest 3 of 9)
!   the Smith chart shows 122 MHz to 141 MHz only
!   S11 on the Smith chart (normalised r, x): 122 MHz: 0.53, +0.15; 125 MHz: 0.65, -0.25; 129 MHz: 0.82, -0.03; 136 MHz: 1.37, +0.38; 139 MHz: 0.74, +0.47; 141 MHz: 0.80, -0.57
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! magnitudes (dB):
! f  S11
! 1 MHz  -23.2
! 15 MHz  -10.2
! 22 MHz  -38.5
! 33 MHz  -9.0
! 44 MHz  -34.5
! 53 MHz  -9.4
! 65 MHz  -31.7
! 77 MHz  -9.4
! 87 MHz  -34.5
! 97 MHz  -9.7
! 109 MHz  -39.5
! 122 MHz  -10.0
! 125 MHz  -11.8
! 129 MHz  -19.9
! 131 MHz  -45.8
! 136 MHz  -13.1
! 139 MHz  -10.5
! 141 MHz  -9.9
! 153 MHz  -42.2
! 161 MHz  -10.5
! 175 MHz  -37.6
! 180 MHz  -12.9
! 193 MHz  -15.7
! 211 MHz  -11.1
! 218 MHz  -33.1
! 225 MHz  -11.8
! 240 MHz  -36.0
! 256 MHz  -12.3
